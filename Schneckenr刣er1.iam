# Autodesk Inventor assembly: Schneckenräder
## iProperties
Created: 2008-11
Part Number: Schneckenräder
Document SubType Name: Assembly
Designer: nkrapf
ClientObjectVersion: 1
Author: nkrapf
